# Repository tokai-student-rocket-project/H-60-Avionics

File README.md:

# H-60-Avionics
H-60搭載計器 すばる1.2 | 2024年度 冬季 大樹

すばる1.1の機能を持ちつつ[第6世代GSE](https://github.com/tokai-student-rocket-project/Gen6-GSE-Elec) に対応しました．

## 回路図・ボード図

- [Flight Module](https://github.com/tokai-student-rocket-project/H-60-Avionics/tree/main/KiCad/FlightModule)
- [Power Module](https://github.com/tokai-student-rocket-project/H-60-Avionics/tree/main/KiCad/PowerModule)
- [Sensing Module](https://github.com/tokai-student-rocket-project/H-60-Avionics/tree/main/KiCad/SensingModule)
- [基板外形](https://github.com/tokai-student-rocket-project/H-60-Avionics/tree/main/KiCad/StandardModuleBoardShape)

## 報告書
- [H-60　報告書](https://github.com/tokai-student-rocket-project/H-60-Avionics/blob/main/Analysis/H-60_%E5%A0%B1%E5%91%8A%E6%9B%B8.pdf)

## ディレクトリ構成図

PlatformIO により自動生成されるフォルダを含めたディレクトリ構成です．

<pre>
├─.pio                    // 自動生成
├─include                 // 特に使用しない
├─lib                     // 自作ライブラリの保存先
│  ├─B3MSC1170A
│  ├─IcsBaseClass
│  ├─IcsHardSerialClass
│  ├─Lib_ADXL375
│  ├─Lib_Altimeter
│  ├─Lib_BNO055
│  ├─Lib_Buzzer
│  ├─Lib_CAN
│  ├─Lib_CountDetector
│  ├─Lib_FlightMode
│  ├─Lib_FlightPin
│  ├─Lib_FlightTime
│  ├─Lib_FRAM
│  ├─Lib_GNSS
│  ├─Lib_GseSignal
│  ├─Lib_Logger1
│  ├─Lib_Logger2
│  ├─Lib_Logger4
│  ├─Lib_OutputPin
│  ├─Lib_PowerMonitor
│  ├─Lib_RateMonitor
│  ├─Lib_Shiranui
│  ├─Lib_Telemeter
│  ├─Lib_Thermistor
│  ├─Lib_Var
│  └─RS405CB
├─src                     // ソースコードの保存先
│  ├─Flight              // 各モジュールたち
│  │  ├─FlightModule
│  │  ├─MissionModule
│  │  ├─SensingModule
│  │  ├─SutegomaModule
│  │  └─ValveControlModule
│  ├─Ground              // 地上局
│  │  ├─CSV
│  │  │  ├─FlightModule
│  │  │  └─SensingModule
│  │  └─JSON
│  │      ├─FlightModule
│  │      └─SensingModule
│  └─LogDumper            // ログを読み出すとき
│      ├─FlightModule
│      ├─MissionModule
│      └─SensingModule
│
└─platformio.ini           // PlatformIOの設定ファイル
└─README.md                // このファイル
</pre>

---

## ライブラリでエラーが出るとき

MsgPacketizer.h, Packetizer.h, MsgPack.h は自身の環境に直接クローンする

**場所**

- Flight Module[Flihgt]

  - .pio > libdeps > FlightModule

- Mission Module[Flight]

 - .pio > libdeps > MissionModule

- Sensing Module[Flight]

  - .pio > libdeps > Sensing Module

- Valve Control Module[Flight]

  - .pio > libdeps > Valve Control Module

- Flight Module[Ground]

  - .pio > libdeps > GroundFlightModule

- Sensing Module[Ground]

  - .pio > libdeps > GroundSensingModule

## KiCad design KiCad/BBM-RP2040/BBM-RP2040.kicad_pcb

Parts:
C1, C2: 10p; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C3, C5: 10u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C4, C6, C7, C10, C11, C12, C13, C14, C15, C16: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C8, C9: 1u; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
D1, D4: D_Schottky; D_SOD-123F
D2, D3: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
J1: USB_B_Micro; ZX62B5PA33
J2, J3: Conn_01x20_Socket; PinSocket_1x18_P2.54mm_Vertical
Q1: PMOS; SOT-23
R1: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2: Do Not Fit; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R4: ~100Max; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R5, R6: 100; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R7, R8: 27.4; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1, SW2: SW_MEC_5E; SMT_4.2X3.2_
U2: W25Q128JVS; SOIC-8_5.23x5.23mm_P1.27mm
U3: RP2040; RP2040-QFN-56
U4: AZ1117-3.3; SOT-223
Y1: Crystal_GND24; Crystal_SMD_SeikoEpson_FA238V-4Pin_3.2x2.5mm

Connections:
+1V1: C6.2, C7.2, C8.2, U3.23 (DVDD), U3.45 (VREG_VOUT), U3.50 (DVDD)
+3.3V: C4.2, C5.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, D4.2 (A), J2.17, J3.17, R2.1, R3.1, R5.1, U2.8 (VCC), U3.1 (IOVDD), U3.10 (IOVDD), U3.22 (IOVDD), U3.33 (IOVDD), U3.42 (IOVDD), U3.43 (ADC_AVDD), U3.44 (VREG_IN), U3.48 (USB_VDD), U3.49 (IOVDD), U4.2 (VO); also elsewhere on the board
+5V: J2.4, Q1.1 (D)
/PchGate-VBUS: D1.2 (A), J1.1 (VBUS), Q1.2 (G)
/PchSource-Vin: C3.1, D1.1 (K), D4.1 (K), Q1.3 (S), U4.3 (VI)
/QSPI_SS: R1.2, R2.2, U2.1 (~CS), U3.56 (QSPI_SS)
/~USB_BOOT: R1.1, SW1.3 (K), SW1.4 (A)
GND: C1.2, C2.2, C3.2, C4.1, C5.2, C6.1, C7.1, C8.1, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, D2.1 (K), D3.1 (K), J1.5 (MP1), J1.6 (MP2), J1.7 (MP3), J1.8 (MP4), J1.9 (MP5), J1.10 (MP6), J2.18, J3.18, SW1.1, SW1.2, SW2.1, SW2.2, U2.4 (GND), U3.19 (TESTEN), U3.57 (GND), U4.1 (GND), Y1.2, Y1.4; also elsewhere on the board
GPIO0: J3.1, U3.2 (GPIO0)
GPIO1: J3.2, U3.3 (GPIO1)
GPIO2: J3.3, U3.4 (GPIO2)
GPIO3: J3.4, U3.5 (GPIO3)
GPIO4: J3.5, U3.6 (GPIO4)
GPIO5: J3.6, U3.7 (GPIO5)
GPIO6: J3.7, U3.8 (GPIO6)
GPIO7: J3.8, U3.9 (GPIO7)
GPIO8: J3.9, U3.11 (GPIO8)
GPIO9: J3.10, U3.12 (GPIO9)
GPIO10: J3.11, U3.13 (GPIO10)
GPIO11: J3.12, U3.14 (GPIO11)
GPIO12: J3.13, U3.15 (GPIO12)
GPIO13: J3.14, U3.16 (GPIO13)
GPIO14: J3.15, U3.17 (GPIO14)
GPIO15: J3.16, U3.18 (GPIO15)
GPIO16: J2.14, U3.27 (GPIO16)
GPIO17: J2.13, U3.28 (GPIO17)
GPIO18: J2.12, U3.29 (GPIO18)
GPIO19: J2.11, U3.30 (GPIO19)
GPIO20: J2.10, U3.31 (GPIO20)
GPIO21: J2.9, U3.32 (GPIO21)
GPIO22: J2.8, U3.34 (GPIO22)
GPIO23: J2.7, U3.35 (GPIO23)
GPIO24: J2.6, U3.36 (GPIO24)
GPIO25: J2.5, R6.1, U3.37 (GPIO25)
GPIO26_ADC0: J2.3, U3.38 (GPIO26_ADC0)
GPIO27_ADC1: J2.2, U3.39 (GPIO27_ADC1)
GPIO28_ADC2: J2.1, U3.40 (GPIO28_ADC2)
GPIO29_ADC3: U3.41 (GPIO29_ADC3); also elsewhere on the board
unnamed: C2.1, R4.1, Y1.3
unnamed: D2.2 (A), R5.2
unnamed: D3.2 (A), R6.2
unnamed: R8.2, U3.46 (USB_DM)
unnamed: R7.2, U3.47 (USB_DP)
QSPI_SCLK: U2.6 (CLK), U3.52 (QSPI_SCLK)
QSPI_SD0: U2.5 (DI(IO0)), U3.53 (QSPI_SD0)
QSPI_SD1: U2.2 (DO(IO1)), U3.55 (QSPI_SD1)
QSPI_SD2: U2.3 (IO2), U3.54 (QSPI_SD2)
QSPI_SD3: U2.7 (IO3), U3.51 (QSPI_SD3)
RUN: R3.2, SW2.3 (K), SW2.4 (A), U3.26 (RUN)
SWCLK: J2.16, U3.24 (SWCLK)
SWD: J2.15, U3.25 (SWD)
USB_DM: J1.2 (D-), R8.1
USB_DP: J1.3 (D+), R7.1
XIN: C1.1, U3.20 (XIN), Y1.1
XOUT: R4.2, U3.21 (XOUT)

Notes on the sheet:
Boot
Reset Button
水晶発振器
フラッシュメモリー
電源部
Status LED

Parts:
R9, R10: 10k; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder

Connections:
+3.3V: R9.1; also elsewhere on the board
GND: R10.2; also elsewhere on the board
GPIO29_ADC3: R9.2, R10.1; also elsewhere on the board

Board: 2 copper layers, 29.0 x 55.1 mm, 40 parts (0 on the bottom side), 55 nets.

## KiCad design KiCad/PowerModule/PowerModule.kicad_pcb

Board: 2 copper layers, 110.0 x 95.0 mm, 62 parts (6 on the bottom side), 38 nets.

Parts:
BT1, BT2, BT3, BT4, BT5: CR123A; CA123A_PC
C1, C4, C5, C6, C10, C11, C13, C14: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C2, C3: 0.056uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C7: 2200uF; CP_Radial_D18.0mm_P7.50mm
C8, C9, C12: 10uF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C16: 33uF; CP_Elec_6.3x5.9
D1, D2: Orange; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D3: SR54F; D_SMB_Handsoldering
D4, D5, D6: GS1010FL; D_SOD-123F
D7: Green; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
J1: GPU; Hirose_DF1B
J2: BATTERY; Hirose_DF1B
J3: BUS; Hirose_DF11B-8DP-2DS
J4: MONITOR; Hirose_DF11B-8DP-2DS
J5: MASTER; Hirose_DF1B
Q1, Q2: TK8S06K3L; TO-252-2
Q3, Q5: AO3401A; SOT-23
R1, R2, R7: 2.7kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3, R4, R5, R19: 0.1R; R_2816_7142Metric_Pad3.20x4.45mm_HandSolder
R6, R17: 5.6kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R13, R14, R15, R16: 10kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R18: 3.3kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
TH1, TH2, TH3, TH4: 10kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U1: LTC4353; MSOP-16_3x4mm_P0.5mm
U2, U3, U4, U8: INA219BxDCN; SOT-23-8
U5, U6, U7: NJM7812SDL1; TO-252-2

Connections:
+3.3V: C4.2, C5.2, C6.2, C14.2, J4.1, R13.1, R14.1, R15.1, R16.1, U2.4 (VS), U2.7 (A0), U3.4 (VS), U4.4 (VS), U4.8 (A1), U8.4 (VS), U8.7 (A0), U8.8 (A1)
+12V: J3.1, J3.2, R4.2, R7.2, U8.2 (IN-)
+VSW: C8.2, C9.2, C12.2, D4.1 (K), D5.1 (K), D6.1 (K), R5.2, U4.2 (IN-), U5.1 (IN), U6.1 (IN), U7.1 (IN)
GND: BT5.2 (-), C1.1, C4.1, C5.1, C6.1, C7.2, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, D7.1 (K), J1.1, J3.3, J3.4, J4.2, J5.1, TH1.2, TH2.2, TH3.2, TH4.2, U1.1 (EN2), U1.15 (GND), U1.16 (EN1), U2.3 (GND), U2.8 (A1), U3.3 (GND), U3.7 (A0), U3.8 (A1), U4.3 (GND), U4.7 (A0), U5.2 (GND), U6.2 (GND), U7.2 (GND), U8.3 (GND)
I2C_SCL: J4.4, U2.5 (SCL), U3.5 (SCL), U4.5 (SCL), U8.5 (SCL)
I2C_SDA: J4.3, U2.6 (SDA), U3.6 (SDA), U4.6 (SDA), U8.6 (SDA)
unnamed: BT1.1 (+), J2.1
unnamed: BT1.2 (-), BT2.1 (+)
unnamed: BT2.2 (-), BT3.1 (+)
unnamed: BT3.2 (-), BT4.1 (+)
unnamed: BT4.2 (-), BT5.1 (+)
unnamed: D1.2 (A), R1.1
unnamed: D1.1 (K), U1.9 (ONST1)
unnamed: D2.2 (A), R2.1
unnamed: D2.1 (K), U1.8 (ONST1)
unnamed: C7.1, D3.2 (A), R6.1
unnamed: C16.1, D3.1 (K), Q1.2 (D), Q2.2 (D), Q3.3 (S), R1.2, R2.2, R6.2, R17.1, U1.7 (OUT2), U1.10 (OUT1)
unnamed: C10.2, C11.2, C13.2, D4.2 (A), D5.2 (A), D6.2 (A), R4.1, U5.3 (OUT), U6.3 (OUT), U7.3 (OUT), U8.1 (IN+)
unnamed: D7.2 (A), R7.1
unnamed: J1.2, R3.1, U3.1 (IN+)
unnamed: J2.2, R19.1, U2.1 (IN+)
unnamed: J3.5, J3.6
unnamed: J3.7, J3.8
unnamed: J5.2, R18.2
unnamed: Q1.1 (G), U1.12 (GATE1)
unnamed: C3.2, Q1.3 (S), R3.2, U1.13 (VIN1), U3.2 (IN-)
unnamed: Q2.1 (G), U1.5 (GATE2)
unnamed: C2.2, Q2.3 (S), R19.2, U1.4 (VIN2), U2.2 (IN-)
unnamed: Q3.2 (D), Q5.2 (D)
unnamed: C16.2, Q3.1 (G), Q5.1 (G), R17.2, R18.1
unnamed: Q5.3 (S), R5.1, U4.1 (IN+)
unnamed: C3.1, U1.11 (CPO1)
unnamed: C2.1, U1.6 (CPO2)
unnamed: C1.2, U1.14 (VCC)
VREF_T1: J4.5, R13.2, TH1.1
VREF_T2: J4.6, R14.2, TH2.1
VREF_T3: J4.7, R15.2, TH3.1
VREF_T4: J4.8, R16.2, TH4.1

## KiCad design KiCad/SensingModule/SensingModule.kicad_pcb

Board: 2 copper layers, 110.0 x 95.0 mm, 43 parts (0 on the bottom side), 35 nets.

Parts:
C1: 10uF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C2: 2.2uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C3, C4, C5, C6: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C7, C8: 15pF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1, D2, D5, D6: B; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D3: R; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D4: GS1010FL; D_SOD-123F
J1: BUS; Hirose_DF11B-8DP-2DS
J2: TERMISTOR; Hirose_DF1B
J3: MONITOR; Hirose_DF11B-8DP-2DS
R1, R2, R7, R8: 680R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3, R4, R11, R12, R13, R14, R15: 4.7kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R5: 2.4kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R6: 120R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R9, R10: 10kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U1: Arduino MKR WAN 1310; ARDUINO_ABX00012
U2: NJM7805SDL1; TO-252-2
U3: MCP2562-E-P; DIP-8_W7.62mm
U4: MCP2515-I/P; DIP-18_W7.62mm
U5, U6, U9, U10: MB85RS2MT; DIP-8_W7.62mm
U7: BNO055
U8: BME280
Y1: 8MHz; Crystal_SMD_HC49-SD

Connections:
+3.3V: C5.2, C6.2, J3.1, R3.2, R4.2, R9.1, R10.1, R11.2, R12.2, R13.2, R14.2, R15.2, U1.26 (+3V3), U3.5 (Vio), U4.18 (VDD), U5.3 (~WP), U5.7 (~HOLD), U5.8 (VDD), U6.3 (~WP), U6.7 (~HOLD), U6.8 (VDD), U7.1 (VIN), U8.1 (VDD), U8.3 (SCB), U9.3 (~WP), U9.7 (~HOLD), U9.8 (VDD), U10.3 (~WP), U10.7 (~HOLD), U10.8 (VDD)
+5V: C2.1, C3.1, C4.2, D4.2 (A), U1.27 (VIN), U2.3 (OUT), U3.3 (VDD)
+12V: C1.1, D4.1 (K), J1.1, J1.2, R5.1, U2.1 (IN)
CAN_H: J1.7, J1.8, R6.1, U3.7 (CANH)
CAN_L: J1.5, J1.6, R6.2, U3.6 (CANL)
CAN_RECEIVE_STATUS: R7.1, U1.9 (PA22_TC4-W0/0)
CAN_RX: U3.4 (RXD), U4.2 (RXCAN)
CAN_SEND_STATUS: R8.1, U1.10 (PA23_TC4-W1/1)
CAN_TX: U3.1 (TXD), U4.1 (TXCAN)
GND: C1.2, C2.2, C3.2, C4.1, C5.1, C6.1, C7.2, C8.2, D1.1 (K), D2.1 (K), D3.1 (K), D5.1 (K), D6.1 (K), J1.3, J1.4, J2.1, J3.2, U1.25 (GND), U2.2 (GND), U3.2 (VSS), U3.8 (STBY), U4.9 (VSS), U5.4 (GND), U6.4 (GND), U7.7 (GND), U8.2 (GND), U8.5 (SDO), U9.4 (GND), U10.4 (GND)
I2C_SCK: J3.4, R15.1, U1.21 (PA09_S0_I2C_SCL), U7.4 (SCL/R), U8.6 (SCK)
I2C_SDA: J3.3, R14.1, U1.20 (PA08_S0_I2C_SDA), U7.3 (SDA/T), U8.4 (SDI)
LORA_RECEIVE_STATUS: R1.1, U1.13 (PB10_TCC0-W4/~4)
LORA_SEND_STATUS: R2.1, U1.14 (PB11_TCC0-W5/~5)
unnamed: D1.2 (A), R1.2
unnamed: D2.2 (A), R2.2
unnamed: D3.2 (A), R5.2
unnamed: D5.2 (A), R7.2
unnamed: D6.2 (A), R8.2
unnamed: R9.2, U4.17 (~RESET)
OSC1: C7.1, U4.8 (OSC1), Y1.2
OSC2: C8.1, U4.7 (OSC2), Y1.1
SPI_CS_FRAM0: R4.1, U1.3 (PB02_AIN10/A1), U5.1 (~CS)
SPI_CS_FRAM1: R3.1, U1.4 (PB03_AIN11/A2), U6.1 (~CS)
SPI_CS_FRAM2: R13.1, U1.11 (PA10_TCC0-W2/~2), U9.1 (~CS)
SPI_CS_FRAM3: R12.1, U1.12 (PA11_TCC0-W3/~3), U10.1 (~CS)
SPI_CS_MCP: R11.1, U1.16 (PA21_TCC0-W7), U4.16 (~CS)
SPI_MISO: U1.19 (PA19_S1_MISO), U4.15 (SO), U5.2 (SO), U6.2 (SO), U9.2 (SO), U10.2 (SO)
SPI_MOSI: U1.17 (PA16_S1_MOSI), U4.14 (SI), U5.5 (SI), U6.5 (SI), U9.5 (SI), U10.5 (SI)
SPI_SCLK: U1.18 (PA17_S1_SCK), U4.13 (SCK), U5.6 (SCK), U6.6 (SCK), U9.6 (SCK), U10.6 (SCK)
VREF_T1: J3.5, U1.5 (PA04_AIN4/A3)
VREF_T2: J3.6, U1.6 (PA05_AIN5/A4)
VREF_T3: J3.7, U1.7 (PA06_AIN6/A5)
VREF_T4: J3.8, U1.8 (PA07_AIN7/A6)
VREF_THERMISTOR: J2.2, R10.2, U1.2 (PA02_AIN0/DAC0/A0)

## KiCad design KiCad/FlightModule/FlightModule.kicad_pcb

Parts:
D1, D2, D3: B; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
J1: BUS; Hirose_DF11B-8DP-2DS
R1, R2, R3: 680R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R21, R28: 4.7kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U1: Arduino MKR WAN 1310; ARDUINO_ABX00012; PARTREV 5
U2: Arduino MKR GPS Shield

Connections:
+3.3V: R21.2, R28.2, U1.26 (+3V3), U2.25 (+3V3); also elsewhere on the board
+5V: U1.27 (VIN); also elsewhere on the board
+12V: J1.1, J1.2; also elsewhere on the board
BUZZER: U1.5 (PA04_AIN4/A3); also elsewhere on the board
CAN_H: J1.7, J1.8; also elsewhere on the board
CAN_L: J1.5, J1.6; also elsewhere on the board
CAN_RECEIVE_STATUS: U1.9 (PA22_TC4-W0/0); also elsewhere on the board
CAN_SEND_STATUS: U1.10 (PA23_TC4-W1/1); also elsewhere on the board
FLIGHT_PIN: U1.11 (PA10_TCC0-W2/~2); also elsewhere on the board
GND: D1.1 (K), D2.1 (K), D3.1 (K), J1.3, J1.4, U1.25 (GND), U2.24 (GND); also elsewhere on the board
GNSS_STATUS: R3.1, U1.14 (PB11_TCC0-W5/~5)
LORA_RECEIVE_STATUS: R1.1, U1.7 (PA06_AIN6/A5)
LORA_SEND_STATUS: R2.1, U1.8 (PA07_AIN7/A6)
unnamed: D1.2 (A), R1.2
unnamed: D2.2 (A), R2.2
unnamed: D3.2 (A), R3.2
SN3: U1.13 (PB10_TCC0-W4/~4); also elsewhere on the board
SN4: U1.12 (PA11_TCC0-W3/~3); also elsewhere on the board
SPI_CS_FRAM: R21.1, U1.16 (PA21_TCC0-W7); also elsewhere on the board
SPI_CS_MCP: R28.1, U1.15 (PA20_TCC0-W6); also elsewhere on the board
SPI_MISO: U1.19 (PA19_S1_MISO); also elsewhere on the board
SPI_MOSI: U1.17 (PA16_S1_MOSI); also elsewhere on the board
SPI_SCLK: U1.18 (PA17_S1_SCK); also elsewhere on the board
VREF_12V: U1.2 (PA02_AIN0/DAC0/A0); also elsewhere on the board
VREF_BATT: U1.4 (PB03_AIN11/A2); also elsewhere on the board
VREF_VSW: U1.3 (PB02_AIN10/A1); also elsewhere on the board

Parts:
C3, C4, C5: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C6, C7: 15pF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D6, D7: B; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R11: 120R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R12, R13: 680R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R14: 10kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U4: MCP2562-E-P; DIP-8_W7.62mm
U5: MCP2515-I/P; DIP-18_W7.62mm; MPN MCP2515-I/P
Y1: 8MHz; Crystal_SMD_HC49-SD

Connections:
+3.3V: C4.2, C5.2, R14.1, U4.5 (Vio), U5.18 (VDD); also elsewhere on the board
+5V: C3.2, U4.3 (VDD); also elsewhere on the board
CAN_H: R11.1, U4.7 (CANH); also elsewhere on the board
CAN_L: R11.2, U4.6 (CANL); also elsewhere on the board
CAN_RECEIVE_STATUS: R12.1; also elsewhere on the board
CAN_RX: U4.4 (RXD), U5.2 (RXCAN)
CAN_SEND_STATUS: R13.1; also elsewhere on the board
CAN_TX: U4.1 (TXD), U5.1 (TXCAN)
GND: C3.1, C4.1, C5.1, C6.2, C7.2, D6.1 (K), D7.1 (K), U4.2 (VSS), U4.8 (STBY), U5.9 (VSS); also elsewhere on the board
unnamed: D6.2 (A), R12.2
unnamed: D7.2 (A), R13.2
unnamed: R14.2, U5.17 (~RESET)
OSC1: C6.1, U5.8 (OSC1), Y1.2
OSC2: C7.1, U5.7 (OSC2), Y1.1
SPI_CS_MCP: U5.16 (~CS); also elsewhere on the board
SPI_MISO: U5.15 (SO); also elsewhere on the board
SPI_MOSI: U5.14 (SI); also elsewhere on the board
SPI_SCLK: U5.13 (SCK); also elsewhere on the board

Parts:
D8, D10: G; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D9, D11: GS1010FL; D_SOD-123F
J2: SN3; Hirose_DF1B
J3: SN4; Hirose_DF1B
Q1, Q2: AO3400A; SOT-23
R15, R18: 300R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R16, R19: 10kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R17, R20: 2.4kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder

Connections:
+12V: D9.1 (K), D11.1 (K), J2.2, J3.2, R17.1, R20.1; also elsewhere on the board
GND: Q1.2 (S), Q2.2 (S), R16.1, R19.1; also elsewhere on the board
unnamed: D8.2 (A), R17.2
unnamed: D8.1 (K), D9.2 (A), J2.1, Q1.3 (D)
unnamed: D10.2 (A), R20.2
unnamed: D10.1 (K), D11.2 (A), J3.1, Q2.3 (D)
unnamed: Q1.1 (G), R15.2, R16.2
unnamed: Q2.1 (G), R18.2, R19.2
SN3: R15.1; also elsewhere on the board
SN4: R18.1; also elsewhere on the board

Parts:
C1: 10uF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C2: 2.2uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C10: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D4: R; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D5: GS1010FL; D_SOD-123F
J6: VREF; Hirose_DF1B
R4: 2.4kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R5, R7, R9: 10kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R6, R8, R10: 1.2kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U3: NJM7805SDL1; TO-252-2

Connections:
+5V: C2.1, C10.1, D5.2 (A), U3.3 (OUT); also elsewhere on the board
+12V: C1.1, D5.1 (K), R4.1, R9.2, U3.1 (IN); also elsewhere on the board
GND: C1.2, C2.2, C10.2, D4.1 (K), R6.1, R8.1, R10.1, U3.2 (GND); also elsewhere on the board
unnamed: D4.2 (A), R4.2
unnamed: J6.1, R5.2
unnamed: J6.2, R7.2
VREF_12V: R9.1, R10.2; also elsewhere on the board
VREF_BATT: R5.1, R6.2; also elsewhere on the board
VREF_VSW: R7.1, R8.2; also elsewhere on the board
